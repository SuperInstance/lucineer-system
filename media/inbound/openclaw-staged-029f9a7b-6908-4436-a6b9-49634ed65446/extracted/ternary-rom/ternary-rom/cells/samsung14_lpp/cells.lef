VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;


MACRO ROM_PLUS_X1_hvt
  CLASS CORE ;
  SIZE 0.0900 BY 0.0900 ;
  SYMMETRY X Y ;
  // Drive: X1, Vt: hvt, Leakage: 0.105 pA

  PIN WL
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal1 ;
        RECT 0.0000 0.0810 0.0900 0.0900 ;
    END
  END WL

  PIN BL
    DIRECTION OUTPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal2 ;
        RECT 0.0000 0.0000 0.0900 0.0090 ;
    END
  END BL

  OBS
    LAYER Metal1 ;
      RECT 0.0000 0.0000 0.0900 0.0810 ;
    LAYER Metal2 ;
      RECT 0.0000 0.0090 0.0900 0.0900 ;
  END

END ROM_PLUS_X1_hvt

MACRO ROM_PLUS_X1_lvt
  CLASS CORE ;
  SIZE 0.0900 BY 0.0900 ;
  SYMMETRY X Y ;
  // Drive: X1, Vt: lvt, Leakage: 2.1 pA

  PIN WL
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal1 ;
        RECT 0.0000 0.0810 0.0900 0.0900 ;
    END
  END WL

  PIN BL
    DIRECTION OUTPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal2 ;
        RECT 0.0000 0.0000 0.0900 0.0090 ;
    END
  END BL

  OBS
    LAYER Metal1 ;
      RECT 0.0000 0.0000 0.0900 0.0810 ;
    LAYER Metal2 ;
      RECT 0.0000 0.0090 0.0900 0.0900 ;
  END

END ROM_PLUS_X1_lvt

MACRO ROM_PLUS_X1
  CLASS CORE ;
  SIZE 0.0900 BY 0.0900 ;
  SYMMETRY X Y ;
  // Drive: X1, Vt: std, Leakage: 0.7 pA

  PIN WL
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal1 ;
        RECT 0.0000 0.0810 0.0900 0.0900 ;
    END
  END WL

  PIN BL
    DIRECTION OUTPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal2 ;
        RECT 0.0000 0.0000 0.0900 0.0090 ;
    END
  END BL

  OBS
    LAYER Metal1 ;
      RECT 0.0000 0.0000 0.0900 0.0810 ;
    LAYER Metal2 ;
      RECT 0.0000 0.0090 0.0900 0.0900 ;
  END

END ROM_PLUS_X1

MACRO ROM_PLUS_X2_hvt
  CLASS CORE ;
  SIZE 0.1800 BY 0.0900 ;
  SYMMETRY X Y ;
  // Drive: X2, Vt: hvt, Leakage: 0.21 pA

  PIN WL
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal1 ;
        RECT 0.0000 0.0810 0.1800 0.0900 ;
    END
  END WL

  PIN BL
    DIRECTION OUTPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal2 ;
        RECT 0.0000 0.0000 0.1800 0.0090 ;
    END
  END BL

  OBS
    LAYER Metal1 ;
      RECT 0.0000 0.0000 0.1800 0.0810 ;
    LAYER Metal2 ;
      RECT 0.0000 0.0090 0.1800 0.0900 ;
  END

END ROM_PLUS_X2_hvt

MACRO ROM_PLUS_X2_lvt
  CLASS CORE ;
  SIZE 0.1800 BY 0.0900 ;
  SYMMETRY X Y ;
  // Drive: X2, Vt: lvt, Leakage: 4.2 pA

  PIN WL
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal1 ;
        RECT 0.0000 0.0810 0.1800 0.0900 ;
    END
  END WL

  PIN BL
    DIRECTION OUTPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal2 ;
        RECT 0.0000 0.0000 0.1800 0.0090 ;
    END
  END BL

  OBS
    LAYER Metal1 ;
      RECT 0.0000 0.0000 0.1800 0.0810 ;
    LAYER Metal2 ;
      RECT 0.0000 0.0090 0.1800 0.0900 ;
  END

END ROM_PLUS_X2_lvt

MACRO ROM_PLUS_X2
  CLASS CORE ;
  SIZE 0.1800 BY 0.0900 ;
  SYMMETRY X Y ;
  // Drive: X2, Vt: std, Leakage: 1.4 pA

  PIN WL
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal1 ;
        RECT 0.0000 0.0810 0.1800 0.0900 ;
    END
  END WL

  PIN BL
    DIRECTION OUTPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal2 ;
        RECT 0.0000 0.0000 0.1800 0.0090 ;
    END
  END BL

  OBS
    LAYER Metal1 ;
      RECT 0.0000 0.0000 0.1800 0.0810 ;
    LAYER Metal2 ;
      RECT 0.0000 0.0090 0.1800 0.0900 ;
  END

END ROM_PLUS_X2

MACRO ROM_PLUS_X4_hvt
  CLASS CORE ;
  SIZE 0.3600 BY 0.0900 ;
  SYMMETRY X Y ;
  // Drive: X4, Vt: hvt, Leakage: 0.42 pA

  PIN WL
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal1 ;
        RECT 0.0000 0.0810 0.3600 0.0900 ;
    END
  END WL

  PIN BL
    DIRECTION OUTPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal2 ;
        RECT 0.0000 0.0000 0.3600 0.0090 ;
    END
  END BL

  OBS
    LAYER Metal1 ;
      RECT 0.0000 0.0000 0.3600 0.0810 ;
    LAYER Metal2 ;
      RECT 0.0000 0.0090 0.3600 0.0900 ;
  END

END ROM_PLUS_X4_hvt

MACRO ROM_PLUS_X4_lvt
  CLASS CORE ;
  SIZE 0.3600 BY 0.0900 ;
  SYMMETRY X Y ;
  // Drive: X4, Vt: lvt, Leakage: 8.4 pA

  PIN WL
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal1 ;
        RECT 0.0000 0.0810 0.3600 0.0900 ;
    END
  END WL

  PIN BL
    DIRECTION OUTPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal2 ;
        RECT 0.0000 0.0000 0.3600 0.0090 ;
    END
  END BL

  OBS
    LAYER Metal1 ;
      RECT 0.0000 0.0000 0.3600 0.0810 ;
    LAYER Metal2 ;
      RECT 0.0000 0.0090 0.3600 0.0900 ;
  END

END ROM_PLUS_X4_lvt

MACRO ROM_PLUS_X4
  CLASS CORE ;
  SIZE 0.3600 BY 0.0900 ;
  SYMMETRY X Y ;
  // Drive: X4, Vt: std, Leakage: 2.8 pA

  PIN WL
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal1 ;
        RECT 0.0000 0.0810 0.3600 0.0900 ;
    END
  END WL

  PIN BL
    DIRECTION OUTPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal2 ;
        RECT 0.0000 0.0000 0.3600 0.0090 ;
    END
  END BL

  OBS
    LAYER Metal1 ;
      RECT 0.0000 0.0000 0.3600 0.0810 ;
    LAYER Metal2 ;
      RECT 0.0000 0.0090 0.3600 0.0900 ;
  END

END ROM_PLUS_X4

MACRO ROM_MINUS_X1_hvt
  CLASS CORE ;
  SIZE 0.0900 BY 0.0900 ;
  SYMMETRY X Y ;
  // Drive: X1, Vt: hvt, Leakage: 0.105 pA

  PIN WL
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal1 ;
        RECT 0.0000 0.0810 0.0900 0.0900 ;
    END
  END WL

  PIN BL
    DIRECTION OUTPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal2 ;
        RECT 0.0000 0.0000 0.0900 0.0090 ;
    END
  END BL

  OBS
    LAYER Metal1 ;
      RECT 0.0000 0.0000 0.0900 0.0810 ;
    LAYER Metal2 ;
      RECT 0.0000 0.0090 0.0900 0.0900 ;
  END

END ROM_MINUS_X1_hvt

MACRO ROM_MINUS_X1_lvt
  CLASS CORE ;
  SIZE 0.0900 BY 0.0900 ;
  SYMMETRY X Y ;
  // Drive: X1, Vt: lvt, Leakage: 2.1 pA

  PIN WL
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal1 ;
        RECT 0.0000 0.0810 0.0900 0.0900 ;
    END
  END WL

  PIN BL
    DIRECTION OUTPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal2 ;
        RECT 0.0000 0.0000 0.0900 0.0090 ;
    END
  END BL

  OBS
    LAYER Metal1 ;
      RECT 0.0000 0.0000 0.0900 0.0810 ;
    LAYER Metal2 ;
      RECT 0.0000 0.0090 0.0900 0.0900 ;
  END

END ROM_MINUS_X1_lvt

MACRO ROM_MINUS_X1
  CLASS CORE ;
  SIZE 0.0900 BY 0.0900 ;
  SYMMETRY X Y ;
  // Drive: X1, Vt: std, Leakage: 0.7 pA

  PIN WL
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal1 ;
        RECT 0.0000 0.0810 0.0900 0.0900 ;
    END
  END WL

  PIN BL
    DIRECTION OUTPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal2 ;
        RECT 0.0000 0.0000 0.0900 0.0090 ;
    END
  END BL

  OBS
    LAYER Metal1 ;
      RECT 0.0000 0.0000 0.0900 0.0810 ;
    LAYER Metal2 ;
      RECT 0.0000 0.0090 0.0900 0.0900 ;
  END

END ROM_MINUS_X1

MACRO ROM_MINUS_X2_hvt
  CLASS CORE ;
  SIZE 0.1800 BY 0.0900 ;
  SYMMETRY X Y ;
  // Drive: X2, Vt: hvt, Leakage: 0.21 pA

  PIN WL
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal1 ;
        RECT 0.0000 0.0810 0.1800 0.0900 ;
    END
  END WL

  PIN BL
    DIRECTION OUTPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal2 ;
        RECT 0.0000 0.0000 0.1800 0.0090 ;
    END
  END BL

  OBS
    LAYER Metal1 ;
      RECT 0.0000 0.0000 0.1800 0.0810 ;
    LAYER Metal2 ;
      RECT 0.0000 0.0090 0.1800 0.0900 ;
  END

END ROM_MINUS_X2_hvt

MACRO ROM_MINUS_X2_lvt
  CLASS CORE ;
  SIZE 0.1800 BY 0.0900 ;
  SYMMETRY X Y ;
  // Drive: X2, Vt: lvt, Leakage: 4.2 pA

  PIN WL
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal1 ;
        RECT 0.0000 0.0810 0.1800 0.0900 ;
    END
  END WL

  PIN BL
    DIRECTION OUTPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal2 ;
        RECT 0.0000 0.0000 0.1800 0.0090 ;
    END
  END BL

  OBS
    LAYER Metal1 ;
      RECT 0.0000 0.0000 0.1800 0.0810 ;
    LAYER Metal2 ;
      RECT 0.0000 0.0090 0.1800 0.0900 ;
  END

END ROM_MINUS_X2_lvt

MACRO ROM_MINUS_X2
  CLASS CORE ;
  SIZE 0.1800 BY 0.0900 ;
  SYMMETRY X Y ;
  // Drive: X2, Vt: std, Leakage: 1.4 pA

  PIN WL
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal1 ;
        RECT 0.0000 0.0810 0.1800 0.0900 ;
    END
  END WL

  PIN BL
    DIRECTION OUTPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal2 ;
        RECT 0.0000 0.0000 0.1800 0.0090 ;
    END
  END BL

  OBS
    LAYER Metal1 ;
      RECT 0.0000 0.0000 0.1800 0.0810 ;
    LAYER Metal2 ;
      RECT 0.0000 0.0090 0.1800 0.0900 ;
  END

END ROM_MINUS_X2

MACRO ROM_MINUS_X4_hvt
  CLASS CORE ;
  SIZE 0.3600 BY 0.0900 ;
  SYMMETRY X Y ;
  // Drive: X4, Vt: hvt, Leakage: 0.42 pA

  PIN WL
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal1 ;
        RECT 0.0000 0.0810 0.3600 0.0900 ;
    END
  END WL

  PIN BL
    DIRECTION OUTPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal2 ;
        RECT 0.0000 0.0000 0.3600 0.0090 ;
    END
  END BL

  OBS
    LAYER Metal1 ;
      RECT 0.0000 0.0000 0.3600 0.0810 ;
    LAYER Metal2 ;
      RECT 0.0000 0.0090 0.3600 0.0900 ;
  END

END ROM_MINUS_X4_hvt

MACRO ROM_MINUS_X4_lvt
  CLASS CORE ;
  SIZE 0.3600 BY 0.0900 ;
  SYMMETRY X Y ;
  // Drive: X4, Vt: lvt, Leakage: 8.4 pA

  PIN WL
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal1 ;
        RECT 0.0000 0.0810 0.3600 0.0900 ;
    END
  END WL

  PIN BL
    DIRECTION OUTPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal2 ;
        RECT 0.0000 0.0000 0.3600 0.0090 ;
    END
  END BL

  OBS
    LAYER Metal1 ;
      RECT 0.0000 0.0000 0.3600 0.0810 ;
    LAYER Metal2 ;
      RECT 0.0000 0.0090 0.3600 0.0900 ;
  END

END ROM_MINUS_X4_lvt

MACRO ROM_MINUS_X4
  CLASS CORE ;
  SIZE 0.3600 BY 0.0900 ;
  SYMMETRY X Y ;
  // Drive: X4, Vt: std, Leakage: 2.8 pA

  PIN WL
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal1 ;
        RECT 0.0000 0.0810 0.3600 0.0900 ;
    END
  END WL

  PIN BL
    DIRECTION OUTPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal2 ;
        RECT 0.0000 0.0000 0.3600 0.0090 ;
    END
  END BL

  OBS
    LAYER Metal1 ;
      RECT 0.0000 0.0000 0.3600 0.0810 ;
    LAYER Metal2 ;
      RECT 0.0000 0.0090 0.3600 0.0900 ;
  END

END ROM_MINUS_X4

MACRO ROM_ZERO_X1_hvt
  CLASS CORE ;
  SIZE 0.0900 BY 0.0900 ;
  SYMMETRY X Y ;
  // Drive: X1, Vt: hvt, Leakage: 0.0 pA

  PIN WL
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal1 ;
        RECT 0.0000 0.0810 0.0900 0.0900 ;
    END
  END WL

  PIN BL
    DIRECTION OUTPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal2 ;
        RECT 0.0000 0.0000 0.0900 0.0090 ;
    END
  END BL

  OBS
    LAYER Metal1 ;
      RECT 0.0000 0.0000 0.0900 0.0810 ;
    LAYER Metal2 ;
      RECT 0.0000 0.0090 0.0900 0.0900 ;
  END

END ROM_ZERO_X1_hvt

MACRO ROM_ZERO_X1_lvt
  CLASS CORE ;
  SIZE 0.0900 BY 0.0900 ;
  SYMMETRY X Y ;
  // Drive: X1, Vt: lvt, Leakage: 0.0 pA

  PIN WL
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal1 ;
        RECT 0.0000 0.0810 0.0900 0.0900 ;
    END
  END WL

  PIN BL
    DIRECTION OUTPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal2 ;
        RECT 0.0000 0.0000 0.0900 0.0090 ;
    END
  END BL

  OBS
    LAYER Metal1 ;
      RECT 0.0000 0.0000 0.0900 0.0810 ;
    LAYER Metal2 ;
      RECT 0.0000 0.0090 0.0900 0.0900 ;
  END

END ROM_ZERO_X1_lvt

MACRO ROM_ZERO_X1
  CLASS CORE ;
  SIZE 0.0900 BY 0.0900 ;
  SYMMETRY X Y ;
  // Drive: X1, Vt: std, Leakage: 0.0 pA

  PIN WL
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal1 ;
        RECT 0.0000 0.0810 0.0900 0.0900 ;
    END
  END WL

  PIN BL
    DIRECTION OUTPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal2 ;
        RECT 0.0000 0.0000 0.0900 0.0090 ;
    END
  END BL

  OBS
    LAYER Metal1 ;
      RECT 0.0000 0.0000 0.0900 0.0810 ;
    LAYER Metal2 ;
      RECT 0.0000 0.0090 0.0900 0.0900 ;
  END

END ROM_ZERO_X1

MACRO ROM_ZERO_X2_hvt
  CLASS CORE ;
  SIZE 0.1800 BY 0.0900 ;
  SYMMETRY X Y ;
  // Drive: X2, Vt: hvt, Leakage: 0.0 pA

  PIN WL
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal1 ;
        RECT 0.0000 0.0810 0.1800 0.0900 ;
    END
  END WL

  PIN BL
    DIRECTION OUTPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal2 ;
        RECT 0.0000 0.0000 0.1800 0.0090 ;
    END
  END BL

  OBS
    LAYER Metal1 ;
      RECT 0.0000 0.0000 0.1800 0.0810 ;
    LAYER Metal2 ;
      RECT 0.0000 0.0090 0.1800 0.0900 ;
  END

END ROM_ZERO_X2_hvt

MACRO ROM_ZERO_X2_lvt
  CLASS CORE ;
  SIZE 0.1800 BY 0.0900 ;
  SYMMETRY X Y ;
  // Drive: X2, Vt: lvt, Leakage: 0.0 pA

  PIN WL
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal1 ;
        RECT 0.0000 0.0810 0.1800 0.0900 ;
    END
  END WL

  PIN BL
    DIRECTION OUTPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal2 ;
        RECT 0.0000 0.0000 0.1800 0.0090 ;
    END
  END BL

  OBS
    LAYER Metal1 ;
      RECT 0.0000 0.0000 0.1800 0.0810 ;
    LAYER Metal2 ;
      RECT 0.0000 0.0090 0.1800 0.0900 ;
  END

END ROM_ZERO_X2_lvt

MACRO ROM_ZERO_X2
  CLASS CORE ;
  SIZE 0.1800 BY 0.0900 ;
  SYMMETRY X Y ;
  // Drive: X2, Vt: std, Leakage: 0.0 pA

  PIN WL
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal1 ;
        RECT 0.0000 0.0810 0.1800 0.0900 ;
    END
  END WL

  PIN BL
    DIRECTION OUTPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal2 ;
        RECT 0.0000 0.0000 0.1800 0.0090 ;
    END
  END BL

  OBS
    LAYER Metal1 ;
      RECT 0.0000 0.0000 0.1800 0.0810 ;
    LAYER Metal2 ;
      RECT 0.0000 0.0090 0.1800 0.0900 ;
  END

END ROM_ZERO_X2

MACRO ROM_ZERO_X4_hvt
  CLASS CORE ;
  SIZE 0.3600 BY 0.0900 ;
  SYMMETRY X Y ;
  // Drive: X4, Vt: hvt, Leakage: 0.0 pA

  PIN WL
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal1 ;
        RECT 0.0000 0.0810 0.3600 0.0900 ;
    END
  END WL

  PIN BL
    DIRECTION OUTPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal2 ;
        RECT 0.0000 0.0000 0.3600 0.0090 ;
    END
  END BL

  OBS
    LAYER Metal1 ;
      RECT 0.0000 0.0000 0.3600 0.0810 ;
    LAYER Metal2 ;
      RECT 0.0000 0.0090 0.3600 0.0900 ;
  END

END ROM_ZERO_X4_hvt

MACRO ROM_ZERO_X4_lvt
  CLASS CORE ;
  SIZE 0.3600 BY 0.0900 ;
  SYMMETRY X Y ;
  // Drive: X4, Vt: lvt, Leakage: 0.0 pA

  PIN WL
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal1 ;
        RECT 0.0000 0.0810 0.3600 0.0900 ;
    END
  END WL

  PIN BL
    DIRECTION OUTPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal2 ;
        RECT 0.0000 0.0000 0.3600 0.0090 ;
    END
  END BL

  OBS
    LAYER Metal1 ;
      RECT 0.0000 0.0000 0.3600 0.0810 ;
    LAYER Metal2 ;
      RECT 0.0000 0.0090 0.3600 0.0900 ;
  END

END ROM_ZERO_X4_lvt

MACRO ROM_ZERO_X4
  CLASS CORE ;
  SIZE 0.3600 BY 0.0900 ;
  SYMMETRY X Y ;
  // Drive: X4, Vt: std, Leakage: 0.0 pA

  PIN WL
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal1 ;
        RECT 0.0000 0.0810 0.3600 0.0900 ;
    END
  END WL

  PIN BL
    DIRECTION OUTPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal2 ;
        RECT 0.0000 0.0000 0.3600 0.0090 ;
    END
  END BL

  OBS
    LAYER Metal1 ;
      RECT 0.0000 0.0000 0.3600 0.0810 ;
    LAYER Metal2 ;
      RECT 0.0000 0.0090 0.3600 0.0900 ;
  END

END ROM_ZERO_X4

MACRO ROM_REF_HI
  CLASS CORE ;
  SIZE 0.0900 BY 0.0900 ;
  SYMMETRY X Y ;
  // Drive: X1, Vt: std, Leakage: 0.7 pA

  PIN WL
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal1 ;
        RECT 0.0000 0.0810 0.0900 0.0900 ;
    END
  END WL

  PIN BL
    DIRECTION OUTPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal2 ;
        RECT 0.0000 0.0000 0.0900 0.0090 ;
    END
  END BL

  OBS
    LAYER Metal1 ;
      RECT 0.0000 0.0000 0.0900 0.0810 ;
    LAYER Metal2 ;
      RECT 0.0000 0.0090 0.0900 0.0900 ;
  END

END ROM_REF_HI

MACRO ROM_REF_LO
  CLASS CORE ;
  SIZE 0.0900 BY 0.0900 ;
  SYMMETRY X Y ;
  // Drive: X1, Vt: std, Leakage: 0.7 pA

  PIN WL
    DIRECTION INPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal1 ;
        RECT 0.0000 0.0810 0.0900 0.0900 ;
    END
  END WL

  PIN BL
    DIRECTION OUTPUT ;
    USE SIGNAL ;
    PORT
      LAYER Metal2 ;
        RECT 0.0000 0.0000 0.0900 0.0090 ;
    END
  END BL

  OBS
    LAYER Metal1 ;
      RECT 0.0000 0.0000 0.0900 0.0810 ;
    LAYER Metal2 ;
      RECT 0.0000 0.0090 0.0900 0.0900 ;
  END

END ROM_REF_LO

END LIBRARY
